# Keil uVision project Project1.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: Sprints_ARM_MC01\Src\Mcal\Inc;Sprints_ARM_MC01\Src\Common;Sprints_ARM_MC01\Src\Config\Inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Mcl
    Sprints_ARM_MC01/Src/Mcal/: IntCtrl.c Dio.c Port.c
    ./Sprints_ARM_MC01/Src/Mcal/: SysTick.c
  group Config
    Sprints_ARM_MC01/Src/Config/: IntCtrl_Lcfg.c Port_Lcfg.c
  group Appl
    Sprints_ARM_MC01/Src/Appl/: main.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
